File: Panel/Panel.kicad_pcb (KiCad board)
At the start: 2 copper layers, 70.8 x 128.5 mm, 28 parts

Commit message: Rename
Other:
- board text added: "NanoGris"
- board text removed: "NanoGrids"
